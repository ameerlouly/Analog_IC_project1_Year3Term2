v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {Idead_opamp.sym} 50 10 0 0 {name=x1}
